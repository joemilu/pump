# Keil uVision project TQ2440.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TQ2440 +hex
  AfterMake: fromelf.exe --bin -o @p.bin @p.axf
  c flags: Optim=1
  c include: .\inc
  asm include: .\inc
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x31000000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\config\RunInSDRAM.sct
  group src
    ./src/: 2440init.s 2440slib.s nand.c 2440lib.c Adc.c keyscan.c LCD_TFT.c Main.c memtest.c mmu.c Pic.c profile.c RTC.c SD_MMC.c Touchpanel.c TQ_LOGO.c
  group inc
    ./inc/: 2440addr.h 2440lib.h 2440slib.h 2440usb.h bootpara.h def.h keyscan.h LCD_TFT.h MAIN.h memtest.h mmu.h Nand.h norflash.h Option.h profile.h SD_MMC.h global.h data.h
